# Keil uVision project experiment5.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: experiment5
  c flags: Optim=1 uC99=1
  c include: ;..\experiment5;.\template\Libraries\CMSIS\CM3\CoreSupport;.\template\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\template\Libraries\STM32F10x_StdPeriph_Driver\src;.\template\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s stm32f10x_it.c system_stm32f10x.c main.c configurations.c delay.c
  group Library
    ./template/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
